# Keil uVision project stepper.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stepper +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\User\StepMotor;.\User\TMC2208;.\User\MotionPlan;.\Start;.\Library;.\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group Library
    ./Library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_exti.c
  group System
    ./System/: Delay.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group StepMotor
    ./User/StepMotor/: bsp_stepmotor.c bsp_stepmotor.h
  group TMC2208
    ./User/TMC2208/: bsp_tmc2208.c bsp_tmc2208.h
  group MotionPlan
    ./User/MotionPlan/: bsp_motionplan.c bsp_motionplan.h
